#define DOCTEST_CONFIG_IMPLEMENT_WITH_MAIN
#include <doctest/doctest.h>

#include "utils.h"
#include "samlib.h"
#include "string_utils.h"
#include "U8Char.h"

int sam(int argc, char **argv) { return 0; }

TEST_CASE("util_stoi parses what std::stoi parses")
{
    CHECK(util_stoi("23") == 23);
    CHECK(util_stoi(" 1701") == 1701);
    CHECK(util_stoi("-1") == -1);
    CHECK(util_stoi("8080/") == 8080);
}

TEST_CASE("util_stoi returns nullopt where std::stoi throws")
{
    CHECK_FALSE(util_stoi("").has_value());
    CHECK_FALSE(util_stoi("//10.4.0.19:1701").has_value());
    CHECK_FALSE(util_stoi("abc").has_value());
    CHECK_FALSE(util_stoi("99999999999999999999").has_value());
}

TEST_CASE("mstr::format prints every argument")
{
    // It measures the text before printing it; both need the arguments
    CHECK(mstr::format("%.2f %s", 63.99, "K") == "63.99 K");
    CHECK(mstr::format("%.16s|%.5s|%d", "FUJINET DISK", "FN 2A", 42) == "FUJINET DISK|FN 2A|42");
}

TEST_CASE("mstr::formatBytes")
{
    CHECK(mstr::formatBytes(65535) == "64.00 K");
    CHECK(mstr::formatBytes(3 * 1024 * 1024) == "3.00 M");
}

TEST_CASE("mstr::toUTF8 converts PETSCII bytes from 0x80 up and drops NUL")
{
    for (int code = 0x80; code <= 0xFF; code++)
    {
        const char petscii = static_cast<char>(code);
        std::string expected = U8Char(petscii).toUtf8();
        CAPTURE(code);
        REQUIRE_FALSE(expected.empty());
        CHECK(mstr::toUTF8(std::string(1, petscii)) == expected);
    }
    CHECK(mstr::toUTF8(std::string("\0", 1)).empty());
}

// PETSCII repeats $C1-$DA at $61-$7A and $A0-$BF at $E0-$FF
static uint8_t petscii_primary(uint8_t code)
{
    if (code >= 0x61 && code <= 0x7A)
        return code + 0x60;
    if (code >= 0xE0)
        return code - 0x40;
    return code;
}

TEST_CASE("every PETSCII byte survives mstr::toUTF8 and mstr::toPETSCII2")
{
    for (int code = 0x01; code <= 0xFF; code++)
    {
        std::string unicode = mstr::toUTF8(std::string(1, static_cast<char>(code)));
        std::string native = mstr::toPETSCII2(unicode);
        CAPTURE(code);
        REQUIRE(native.size() == 1);
        uint8_t back = static_cast<uint8_t>(native[0]);
        CHECK((back == code || back == petscii_primary(code)));
    }
}

// The C64 lowercase set from https://www.kreativekorp.com/charset/map/petscii/, for the
// characters that fit in 16 bits. U8Char keeps $5C, $5E, $5F, $60, $7B and $7D as ASCII.
static const struct
{
    uint8_t petscii;
    char16_t unicode;
} lowercaseChart[] = {
    {0x20, 0x0020}, {0x21, 0x0021}, {0x22, 0x0022}, {0x23, 0x0023}, {0x24, 0x0024}, {0x25, 0x0025},
    {0x26, 0x0026}, {0x27, 0x0027}, {0x28, 0x0028}, {0x29, 0x0029}, {0x2A, 0x002A}, {0x2B, 0x002B},
    {0x2C, 0x002C}, {0x2D, 0x002D}, {0x2E, 0x002E}, {0x2F, 0x002F}, {0x30, 0x0030}, {0x31, 0x0031},
    {0x32, 0x0032}, {0x33, 0x0033}, {0x34, 0x0034}, {0x35, 0x0035}, {0x36, 0x0036}, {0x37, 0x0037},
    {0x38, 0x0038}, {0x39, 0x0039}, {0x3A, 0x003A}, {0x3B, 0x003B}, {0x3C, 0x003C}, {0x3D, 0x003D},
    {0x3E, 0x003E}, {0x3F, 0x003F}, {0x40, 0x0040}, {0x41, 0x0061}, {0x42, 0x0062}, {0x43, 0x0063},
    {0x44, 0x0064}, {0x45, 0x0065}, {0x46, 0x0066}, {0x47, 0x0067}, {0x48, 0x0068}, {0x49, 0x0069},
    {0x4A, 0x006A}, {0x4B, 0x006B}, {0x4C, 0x006C}, {0x4D, 0x006D}, {0x4E, 0x006E}, {0x4F, 0x006F},
    {0x50, 0x0070}, {0x51, 0x0071}, {0x52, 0x0072}, {0x53, 0x0073}, {0x54, 0x0074}, {0x55, 0x0075},
    {0x56, 0x0076}, {0x57, 0x0077}, {0x58, 0x0078}, {0x59, 0x0079}, {0x5A, 0x007A}, {0x5B, 0x005B},
    {0x5D, 0x005D}, {0x61, 0x0041}, {0x62, 0x0042}, {0x63, 0x0043}, {0x64, 0x0044}, {0x65, 0x0045},
    {0x66, 0x0046}, {0x67, 0x0047}, {0x68, 0x0048}, {0x69, 0x0049}, {0x6A, 0x004A}, {0x6B, 0x004B},
    {0x6C, 0x004C}, {0x6D, 0x004D}, {0x6E, 0x004E}, {0x6F, 0x004F}, {0x70, 0x0050}, {0x71, 0x0051},
    {0x72, 0x0052}, {0x73, 0x0053}, {0x74, 0x0054}, {0x75, 0x0055}, {0x76, 0x0056}, {0x77, 0x0057},
    {0x78, 0x0058}, {0x79, 0x0059}, {0x7A, 0x005A}, {0xA0, 0x00A0}, {0xA1, 0x258C}, {0xA2, 0x2584},
    {0xA3, 0x2594}, {0xA4, 0x2581}, {0xA5, 0x258F}, {0xA6, 0x2592}, {0xA7, 0x2595}, {0xAB, 0x251C},
    {0xAC, 0x2597}, {0xAD, 0x2514}, {0xAE, 0x2510}, {0xAF, 0x2582}, {0xB0, 0x250C}, {0xB1, 0x2534},
    {0xB2, 0x252C}, {0xB3, 0x2524}, {0xB4, 0x258E}, {0xB5, 0x258D}, {0xB9, 0x2583}, {0xBA, 0x2713},
    {0xBB, 0x2596}, {0xBC, 0x259D}, {0xBD, 0x2518}, {0xBE, 0x2598}, {0xBF, 0x259A}, {0xC0, 0x2500},
    {0xC1, 0x0041}, {0xC2, 0x0042}, {0xC3, 0x0043}, {0xC4, 0x0044}, {0xC5, 0x0045}, {0xC6, 0x0046},
    {0xC7, 0x0047}, {0xC8, 0x0048}, {0xC9, 0x0049}, {0xCA, 0x004A}, {0xCB, 0x004B}, {0xCC, 0x004C},
    {0xCD, 0x004D}, {0xCE, 0x004E}, {0xCF, 0x004F}, {0xD0, 0x0050}, {0xD1, 0x0051}, {0xD2, 0x0052},
    {0xD3, 0x0053}, {0xD4, 0x0054}, {0xD5, 0x0055}, {0xD6, 0x0056}, {0xD7, 0x0057}, {0xD8, 0x0058},
    {0xD9, 0x0059}, {0xDA, 0x005A}, {0xDB, 0x253C}, {0xDD, 0x2502}, {0xE0, 0x00A0}, {0xE1, 0x258C},
    {0xE2, 0x2584}, {0xE3, 0x2594}, {0xE4, 0x2581}, {0xE5, 0x258F}, {0xE6, 0x2592}, {0xE7, 0x2595},
    {0xEB, 0x251C}, {0xEC, 0x2597}, {0xED, 0x2514}, {0xEE, 0x2510}, {0xEF, 0x2582}, {0xF0, 0x250C},
    {0xF1, 0x2534}, {0xF2, 0x252C}, {0xF3, 0x2524}, {0xF4, 0x258E}, {0xF5, 0x258D}, {0xF9, 0x2583},
    {0xFA, 0x2713}, {0xFB, 0x2596}, {0xFC, 0x259D}, {0xFD, 0x2518}, {0xFE, 0x2598}, {0xFF, 0x259A},
};

TEST_CASE("U8Char maps PETSCII to the Unicode chart")
{
    for (const auto &entry : lowercaseChart)
    {
        int code = entry.petscii;
        CAPTURE(code);
        CHECK(U8Char(static_cast<char>(entry.petscii)).ch == entry.unicode);
    }
}
